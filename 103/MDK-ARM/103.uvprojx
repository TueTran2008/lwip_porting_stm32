# Keil uVision project 103.uvprojx, settings and files
target 103 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: 103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/lwip-2.1.2/src;../Drivers/lwip-2.1.2/src/api;../Drivers/lwip-2.1.2/src/apps;../Drivers/lwip-2.1.2/src/core;../Drivers/lwip-2.1.2/src/include;../Drivers/lwip-2.1.2/src/netif;../Drivers/lwip-2.1.2/src/include/lwip;../Drivers/lwip-2.1.2/src/include/compat;../Drivers/lwip-2.1.2/src/include/netif;../Drivers/lwip-2.1.2/src/include/lwip/apps;../Drivers/lwip-2.1.2/src/include/lwip/priv;../Drivers/lwip-2.1.2/src/include/lwip/prot;../Drivers/lwip-2.1.2/gsm;../Drivers/lwip-2.1.2/src/include/netif/ppp;../Drivers/lwip-2.1.2/stm32/arch;../Drivers/lwip-2.1.2/stm32/SEGGER_RTT_V698b/RTT;../Drivers/lwip-2.1.2/stm32/SEGGER_RTT_V698b/Syscalls;..Drivers/lwip-2.1.2/stm32/app_debug;..Drivers/Modules/UserUart;..Drivers/Modules/UserUart/cfg;..Drivers/Modules/UserUart/protocol;..Drivers/Modules/UserUart/ip/usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group lwip/core
    ../Drivers/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/netif
    ../Drivers/lwip-2.1.2/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Drivers/lwip-2.1.2/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/ipv4
    ../Drivers/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/porting
    ../Drivers/lwip-2.1.2/stm32/arch/: cc.h cpu.h
    ../Drivers/lwip-2.1.2/stm32/: lwipopts.h sys_timer.c
  group Segger_Rtt
    ../Drivers/lwip-2.1.2/stm32/SEGGER_RTT_V698b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
    ../Drivers/lwip-2.1.2/stm32/SEGGER_RTT_V698b/Syscalls/: SEGGER_RTT_Syscalls_GCC.c SEGGER_RTT_Syscalls_IAR.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_Syscalls_SES.c
  group gsm
    ../Drivers/lwip-2.1.2/gsm/: gsm.h gsm_data_layer.c gsm_hardware_layer.c gsm_utilities.c gsm_utilities.h
  group App_Debug
    ../Drivers/lwip-2.1.2/stm32/app_debug/: app_debug.c app_debug.h
software components: CMSIS:CORE 4.3.0
